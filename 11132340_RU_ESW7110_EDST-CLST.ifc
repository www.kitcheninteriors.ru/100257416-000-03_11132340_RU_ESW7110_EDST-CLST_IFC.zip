Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-06-17T12:22:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 17 12:22:47 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{574E65E5-272C-44F7-8DE4-8F6113245867}\ifc * Database version: 5507 * Database creation date: Thu Jun 17 12:22:46 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 17 12:22:46 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 17 12:22:46 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 30711040_RU_11132340_ESW7110_EDST-CLST, 11132340_RU_ESW7110_EDST-CLST:30711040_RU_11132340_ESW7110_EDST-CLST:204016
In: Level 1
Type - Classification: ESW7000 (Uniformat); Material: z_Miele_Design_CLST, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 30711040_RU_11132340_ESW7110_EDST-CLST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
